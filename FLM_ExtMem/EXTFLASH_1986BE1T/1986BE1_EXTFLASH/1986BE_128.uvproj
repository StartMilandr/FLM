# Keil uVision project 1986BE_128.uvproj, settings and files
target LM3S_128 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: MK1986BE
  AfterMake: cmd.exe /C copy Out\MK1986BE.axf ..\1986BE1_EXTFLASH.FLM
  c flags: Optim=1
  scatter file: .\Target.lin
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
