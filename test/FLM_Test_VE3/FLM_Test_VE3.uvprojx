# Keil uVision project FLM_Test_VE3.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: FLM_Test_VE3
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_MDR1986VE3
  c include: ..\FLM_Test_VE3;..\..\test;..\..\src
  memory RVCT4: ROM 0x20100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../: main.c
    ../../src/: flmClock.c MDR32F9Qx_eeprom.c FlashPrg.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.1
