# Keil uVision project VE1_FLM_FlashIntDR.uvproj, settings and files
target Cortex-M (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1") ESEL
  output: 1986VE1_FlashInt_DR
  AfterMake: cmd.exe /C copy "Obj\%L" "..\..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: USE_MDR1986VE1T, FIX_DBL_READ
  c include: ..\..\src
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../../src/: FlashPrg.c flmClock.c MDR32F9Qx_eeprom.c
  group Device Description
    ./: FlashDev.c
  group Stack Size
    ./: FlashStk.s
target ARM7_ARM9 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: NEW_DEVICE
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLX"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
